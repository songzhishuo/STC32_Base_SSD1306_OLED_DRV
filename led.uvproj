# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: led +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c system.c
    ./IIC/: iic.c
    ./ssd1306/: ssd1306.c ssd1306_fonts.c ssd1306_tests.c
